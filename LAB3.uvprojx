# Keil uVision project LAB3.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LAB3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: MAIN.c main.h IRQ_MAIN.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.1.0, Device:GPIO 1.3, Device:Startup 1.0.0
